# Keil uVision project BMS2.0.uvprojx, settings and files
target BMS2.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BMS2.0
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: GD32F30X_HD
  c include: ..\..\App\Core;..\..\App\User;..\..\Drivers\BSP\LED;..\..\Drivers\CMSIS;..\..\Drivers\GD32F30x_STD_Driver\inc;..\..\Drivers\GD32F30x_STD_Driver;..\..\Middlewares;..\..\Utilities
  asm define: GD32F30X_HD
  memory RVCT1: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Utilities
    ../../Utilities/: delay.c
  group Drives/GD32F30x_STD_Driver
    ../../Drivers/GD32F30x_STD_Driver/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Drives/BSP/LED
    ../../Drivers/BSP/LED/: led_driver.c led_instance.c led_interface.c
  group Drives/CMSIS
    ../../Drivers/CMSIS/: system_gd32f30x.c startup_gd32f30x_hd.s
  group App/Core
    ../../App/Core/: gd32f30x_it.c tim.c usart.c
  group App/User
    ../../App/User/: global.c main.c
